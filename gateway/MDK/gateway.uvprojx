# Keil uVision project gateway.uvprojx, settings and files
target gateway_app (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: HC32F460PETB HDSC
  pack: HDSC.HC32F46x.1.0.6
  cpu: IROM(0x00000000,0x80000) IROM2(0x03000C00,0x3FC) IRAM(0x1FFF8000,0x2F000) IRAM2(0x200F0000,0x1000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: gateway +hex
  AfterMake: fromelf  --bin  -o ./output/release/gateway.bin ./output/gateway.axf
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1
  c define: __DEBUG,HC32F46x,USE_DEVICE_DRIVER_LIB
  c misc: --diag_suppress=186,66
  c include: ..\source;..\source\bsp_common;..\source\bsp_driver\inc;..\source\FreeRTOS;..\source\FreeRTOS\include;..\source\FreeRTOS\portable\MemMang;..\source\FreeRTOS\portable\MDK;..\source\FreeRTOS;..\source\start_task;..\source\indicator;..\source\indicator_task;..\source\contorl_task;..\source\rs458_task;..\source\debug_usart;..\source\ethernet_task;..\source\oled_task;..\source\wifi_task;..\source\data_task;..\..\..\..\..\gateway_v0.1_0522\gateway_v0.1_0522\gateway\source\temp_task;..\source\temp_task;..\source\broker_task;..\source\button_task;..\source;..\source\indicator_task;..\source\logic_control_task;..\source\switch_task;..\source\button_task;..\source\data_task;..\source\gpio_manage_task;..\source\ethernet_task\dns
  library: MicroLIB
  memory RVCT4: ROM 0xe000 size 0x80000
  memory RVCT5: ROM 0x3000c00 size 0x3fc
  memory RVCT9: RAM 0x1fff8000 size 0x2f000
  memory RVCT10: RAM 0x200f0000 size 0x1000
  link misc: --keep=*Handler
  group user
    ../source/: main.c
    ../source/FreeRTOS/: FreeRTOSConfig.h
  group start_task
    ../source/start_task/: start_task.c
  group broker_task
    ../source/broker_task/: broker_task.c
  group logic_control_task
    ../source/logic_control_task/: logic_control_task.c logic_key_handle.c local_hotel_agreement.c ethernet_hotel_agreement.c logic_control_bsp.c
  group gpio_manage_task
    ../source/gpio_manage_task/: gpio_manage_business.c gpio_manage_driver.c gpio_manage_bsp_hc32f64.c
  group data_manage_task
    ../source/data_task/: data_task.c flash_bsp.c
  group ethernet_task
    ../source/ethernet_task/: ethernet_task.c ethernet_operation.c ethernet_data_handle.c ethernet_iap.c socket.c dhcp.c w5500.c wizchip_conf.c spi.c
    ../source/ethernet_task/dns/: dns.c
  group rs458_task
    ../source/rs458_task/: rs458_task.c rs458_analysis.c rs458_bsp.c
  group debug_usart
    ../source/debug_usart/: debug_bsp.c
  group freertos
    ../source/FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../source/FreeRTOS/portable/MemMang/: heap_4.c
    ../source/FreeRTOS/portable/MDK/: port.c
  group bsp_common
    ../source/bsp_driver/src/: hc32f46x_interrupts.c
    ./: startup_hc32f46x.s
    ../source/bsp_common/: system_hc32f46x.c
  group bsp_driver
    ../source/bsp_driver/src/: hc32f46x_gpio.c hc32f46x_utility.c hc32f46x_clk.c hc32f46x_dmac.c hc32f46x_efm.c hc32f46x_pwc.c hc32f46x_usart.c hc32f46x_spi.c hc32f46x_timer0.c hc32f46x_timer6.c hc32f46x_wdt.c
  group readme
    ../source/: readme.txt
target gpio_output_Release (5060020::V5.06 (build 20)::ARMCC)
  device: HC32F460PETB HDSC
  pack: HDSC.HC32F46x.1.0.6
  cpu: IROM(0x00000000,0x80000) IROM2(0x03000C00,0x3FC) IRAM2(0x200F0000,0x1000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: gpio_output +hex
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1
  c define: HC32F46x,USE_DEVICE_DRIVER_LIB
  c misc: --diag_suppress=186,66
  c include: ..\..\..\..\mcu\common;..\source;..\..\..\..\driver\inc;
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT5: ROM 0x3000c00 size 0x3fc
  memory RVCT9: RAM 0x1fff8000 size 0x2f000
  memory RVCT10: RAM 0x200f0000 size 0x1000
  link misc: --keep=*Handler
software components: CMSIS:CORE 5.4.0
